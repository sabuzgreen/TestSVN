options:
  parameters:
    author: Nahid
    generate_options: qt_gui
    id: RFID_SNR_Frequency_Hopping
    output_language: python
    title: RFID SNR Frequency Hopping
  states: {}

blocks:
- name: Length_Mov_AVG
  id: variable
  parameters:
    value: 1024*20
  states: {}
- name: Length_Mov_AVG_INV
  id: variable
  parameters:
    value: 1/Length_Mov_AVG
  states: {}
- name: Level_Gauge
  id: variable_qtgui_label
  parameters:
    label: 'Power[dB]:  '
    type: real
    value: power_measure
  states: {}
- name: Level_Gauge_0
  id: variable_qtgui_label
  parameters:
    label: '"Noise[dB]: "'
    type: real
    value: noise_measure
  states: {}
- name: Level_Gauge_1
  id: variable_qtgui_label
  parameters:
    label: 'Absolute Power[dB]:  '
    type: real
    value: Level_Gauge-Level_Gauge_0
  states: {}
- name: carrier_frequency
  id: variable
  parameters:
    value: python_module_8Frequency.sweeper(function_probe)
  states: {}
- name: filter_shift
  id: variable
  parameters:
    value: 0.01e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: frequency
  id: variable_qtgui_label
  parameters:
    label: 'Frequency[GHz]:  '
    type: real
    value: carrier_frequency
  states: {}
- name: function_probe
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '0.5'
    value: '0'
  states: {}
- name: noOfItems
  id: variable
  parameters:
    value: 1024*200
  states: {}
- name: noise_measure
  id: variable_function_probe
  parameters:
    block_id: noise
    function_name: level
    poll_rate: poll_rate
    value: '0'
  states: {}
- name: poll_rate
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: power_measure
  id: variable_function_probe
  parameters:
    block_id: power
    function_name: level
    poll_rate: poll_rate
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: freq+filter_shift
    low_cutoff_freq: freq-filter_shift
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_shift/2
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: freq-filter_shift
    low_cutoff_freq: freq-filter_shift*2
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: filter_shift/2
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(Length_Mov_AVG)
    max_iter: 10*int(Length_Mov_AVG)
    scale: Length_Mov_AVG_INV
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: int(Length_Mov_AVG)
    max_iter: 10*int(Length_Mov_AVG)
    scale: Length_Mov_AVG_INV
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: noise
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    args: bladerf,biastee=0
    bb_gain0: '20'
    freq0: carrier_frequency
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    args: bladerf,biastee=0
    bb_gain0: '20'
    freq0: carrier_frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: power
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: python_module_8Frequency
  id: epy_module
  parameters:
    source_code: "\r\nf1 = 1240000000\r\nf2 = 1255000000\r\nf3 = 1305000000\r\nf4 = 1388000000\r\nf5 = 1505000000\r\nf6 = 1815000000\r\nf7 = 1840000000\r\nf8 = 1855000000\r\n\r\nstep12 = 150000000\r\n\r\nf = f1\r\nstep = step12\r\nArrayIndex = 0\r\n\r\ndef sweeper(prob_lvl):\r\n\r\n\tglobal f1,f2,f3,f4,f5,f6,f7,f8,f,ArrayIndex,step12,step\r\n\r\n\tif prob_lvl:\r\n\t\tf += step\r\n\t\tArrayIndex =ArrayIndex + 1\r\n\t\t\r\n\tif ArrayIndex == 1: \r\n\t\tf = f2\r\n\t\t\r\n\tif ArrayIndex == 2: \r\n\t\tf = f3\r\n\t\t\r\n\tif ArrayIndex == 3: \r\n\t\tf = f4\r\n\t\t\t\r\n\tif ArrayIndex == 4: \r\n\t\tf = f5\r\n\t\t\r\n\tif ArrayIndex == 5: \r\n\t\tf = f6\r\n\t\t\r\n\tif ArrayIndex == 6: \r\n\t\tf = f7\r\n\t\t\r\n\tif ArrayIndex == 7: \r\n\t\tf = f8\r\n\t\t\r\n\tif f > f8 :\r\n\t\tf = f8\r\n#\t\tf = f1\r\n#\t\tstep = step12\r\n#\t\tArrayIndex =0\r\n\t\t\r\n\treturn f\r\n\r\n\r\n"
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency
    fftsize: '1024'
    grid: 'True'
    label1: Tx_Signal
    name: '"TX Signal"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency
    fftsize: '1024'
    grid: 'True'
    label1: Rx_Filtered_Signal
    name: '"RX Filtered Signal"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency
    fftsize: '1024'
    grid: 'True'
    label1: Rx_Noise_Signal
    name: '"RX Noise Signal"'
    type: complex
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', band_pass_filter_0, '0']
- [analog_sig_source_x_0, '0', band_pass_filter_0_0, '0']
- [analog_sig_source_x_0_0, '0', osmosdr_sink_0_0, '0']
- [analog_sig_source_x_0_0, '0', probe_signal, '0']
- [analog_sig_source_x_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0, '0', power, '0']
- [blocks_nlog10_ff_0_0, '0', noise, '0']
- [osmosdr_source_1, '0', band_pass_filter_0, '0']
- [osmosdr_source_1, '0', band_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
